#include "swpro_spi.h"

#include <stddef.h>
#include <string.h>

typedef struct {
    uint16_t address;
    const uint8_t *data;
    uint16_t length;
} spi_region_t;

static const uint8_t spi_data_6000[] = {
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0x03, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
};

static const uint8_t spi_data_6020[] = {
    0x23, 0x00, 0xB9, 0xFF, 0x1A, 0x01,
    0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
    0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
    0x3B, 0x34, 0x3B, 0x34, 0x3B, 0x34,
};

static const uint8_t spi_data_603D[] = {
    0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80,
    0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80,
    0xFF, 0x2D, 0x2D, 0x2D, 0xE6, 0xE6, 0xE6,
};

static const uint8_t spi_data_6050[] = {
    0x2D, 0x2D, 0x2D, 0xE6, 0xE6, 0xE6,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};

static const uint8_t spi_data_6080[] = {
    0x50, 0xFD, 0x00, 0x00, 0xC6, 0x0F,
    0x0F, 0x30, 0x61, 0xAE, 0x90, 0xD9, 0xD4, 0x14, 0x54,
    0x41, 0x15, 0x54, 0xC7, 0x79, 0x9C, 0x33, 0x36, 0x63,
};

static const uint8_t spi_data_6098[] = {
    0x0F, 0x30, 0x61, 0xAE, 0x90, 0xD9, 0xD4, 0x14, 0x54,
    0x41, 0x15, 0x54, 0xC7, 0x79, 0x9C, 0x33, 0x36, 0x63,
};

static const uint8_t spi_data_8010[22] = {
    [0 ... 21] = 0xFF,
};

static const uint8_t spi_data_8026[26] = {
    [0 ... 25] = 0xFF,
};

static const spi_region_t spi_regions[] = {
    {0x6000, spi_data_6000, sizeof(spi_data_6000)},
    {0x6020, spi_data_6020, sizeof(spi_data_6020)},
    {0x603D, spi_data_603D, sizeof(spi_data_603D)},
    {0x6050, spi_data_6050, sizeof(spi_data_6050)},
    {0x6080, spi_data_6080, sizeof(spi_data_6080)},
    {0x6098, spi_data_6098, sizeof(spi_data_6098)},
    {0x8010, spi_data_8010, sizeof(spi_data_8010)},
    {0x8026, spi_data_8026, sizeof(spi_data_8026)},
};

void switch_spi_read(uint16_t address, uint8_t length, uint8_t *out)
{
    if (out == NULL || length == 0) {
        return;
    }

    const spi_region_t *matched = NULL;
    for (size_t i = 0; i < sizeof(spi_regions) / sizeof(spi_regions[0]); ++i) {
        const spi_region_t *region = &spi_regions[i];
        const uint16_t end = region->address + region->length;
        if (address >= region->address && address < end &&
            (matched == NULL || region->address > matched->address)) {
            matched = region;
        }
    }

    if (matched == NULL) {
        memset(out, 0xFF, length);
        return;
    }

    const uint16_t offset = address - matched->address;
    const uint16_t available = matched->length - offset;
    const uint8_t copy_len = length <= available ? length : (uint8_t)available;
    memcpy(out, matched->data + offset, copy_len);
    memset(out + copy_len, 0xFF, length - copy_len);
}
